** sch_path: schema/ac_probe/ac_probe.sch
**.subckt ac_probe IN OUT
*.iopin IN
*.iopin OUT
C1 net1 IN 1 m=1
V1 net1 0 {vcm} ac {vac}
L1 OUT IN 1G m=1
**.ends
.end
